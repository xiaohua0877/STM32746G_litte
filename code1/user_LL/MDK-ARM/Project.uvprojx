# Keil uVision project Project.uvprojx, settings and files
target STM32F746G_AXIM_FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F746G_AXIM_FLASH
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../Drivers/STM32F7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/STM32F7xx_LL_Driver
    ../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_crc.c stm32f7xx_ll_dma.c stm32f7xx_ll_exti.c stm32f7xx_ll_i2c.c stm32f7xx_ll_rng.c stm32f7xx_ll_tim.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c stm32f7xx_ll_adc.c stm32f7xx_ll_usart.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_spi.c stm32f7xx_ll_gpio.c stm32f7xx_ll_dac.c stm32f7xx_ll_pwr.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Example/User
    ../Src/: stm32f7xx_it.c main.c
    ../Src/usart/: usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
target STM32F746G_ITCM_FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: STM32F746G_ITCM_FLASH +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../Drivers/STM32F7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 4.3.0
