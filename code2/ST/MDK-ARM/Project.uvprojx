# Keil uVision project Project.uvprojx, settings and files
target STM32F746G_AXIM_FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F746G_FLASH
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../Middlewares/Third_Party/uCOS-III/STM32F746G_Disco;../../../Middlewares/Third_Party/uCOS-III/STM32F746G_Disco;../../../Middlewares/Third_Party/uCOS-III/uC-CPU;../../../Middlewares/Third_Party/uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM;../../../Middlewares/Third_Party/uCOS-III/uC-Clk/Source;../../../Middlewares/Third_Party/uCOS-III/uC-LIB;../../../Middlewares/Third_Party/uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView;../../../Middlewares/Third_Party/uCOS-III/uCOS-III/Source;../../../Middlewares/Third_Party/uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/RealView;../../../Middlewares/Third_Party/uCOS-III/uC-LIB;../Crypto;../OS3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Example/User
    ../OS3/: main.c os_app_hooks.c stm32f7xx_it.c os_app_task.c
  group Drivers/CMSIS
    ../OS3/: system_stm32f7xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_LL_Driver
    ../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_crc.c stm32f7xx_ll_dma.c stm32f7xx_ll_exti.c stm32f7xx_ll_i2c.c stm32f7xx_ll_rng.c stm32f7xx_ll_tim.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c stm32f7xx_ll_adc.c stm32f7xx_ll_usart.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_spi.c stm32f7xx_ll_gpio.c stm32f7xx_ll_dac.c stm32f7xx_ll_pwr.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
  group UCOS_BSP
    ../../../Middlewares/Third_Party/uCOS-III/STM32F746G_Disco/: bsp_clk.c bsp_cpu.c bsp_led.c bsp_os.c
  group UCOS_CPU
    ../../../Middlewares/Third_Party/uCOS-III/uC-CPU/: cpu_core.c
    ../../../Middlewares/Third_Party/uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../../Middlewares/Third_Party/uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm cpu.h
  group UCOS_LIB
    ../../../Middlewares/Third_Party/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../Middlewares/Third_Party/uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOS_Core
    ../../../Middlewares/Third_Party/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS_PORT
    ../../../Middlewares/Third_Party/uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../../Middlewares/Third_Party/uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/RealView/: os_cpu.h os_cpu_a.asm
  group UCOS_Interrupts
    ../../../Middlewares/Third_Party/uCOS-III/Interrupts/: bsp_int_armv7m.c
target STM32F746G_ITCM_FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: STM32F746G_ITCM_FLASH +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../Drivers/STM32F7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 4.3.0
